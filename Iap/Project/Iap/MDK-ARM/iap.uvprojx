# Keil uVision project iap.uvprojx, settings and files
target iap (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F205VC STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.9.0
  cpu: IRAM(0x20000000,0x18000) IROM(0x08000000,0x40000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: iap +hex
  AfterMake: pproc.bat
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER,STM32F2XX,USE_USB_OTG_FS,__DISCO__,HSE_VALUE=8000000
  c include: ..\;..\Inc;..\..\..\Libraries\CMSIS\Device\ST\STM32F2xx\Include;..\..\..\Libraries\STM32F2xx_StdPeriph_Driver\inc;..\..\Pfm6Ctrl\inc\app;..\..\..\Utilities\FatFs_R0.09a
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group Main
    ../Src/: main.c
  group stm32f2xx StdPeriph_Driver
    ../../../Libraries/STM32F2xx_StdPeriph_Driver/src/: stm32f2xx_can.c stm32f2xx_crc.c stm32f2xx_gpio.c stm32f2xx_iwdg.c stm32f2xx_rcc.c stm32f2xx_flash.c misc.c
  group Startup 205
    ../Src/: startup_stm32f2xx.s system_stm32f2xx.c
  group FatFs
    ../../../Utilities/FatFs_R0.09a/: diskio.c ff.c
    ../../../Utilities/FatFs_R0.09a/option/: ccsbcs.c
software components: CMSIS:CORE 5.0.1
